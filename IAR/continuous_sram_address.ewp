# IAR project continuous_sram_address.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MCXA156 NXP MCXA156
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 61
  General.FPU2: 6
  ICCARM.CCDefines: DEBUG; PRINTF_FLOAT_ENABLE=0; SCANF_FLOAT_ENABLE=0; PRINTF_ADVANCED_ENABLE=0; SCANF_ADVANCED_ENABLE=0; CPU_MCXA156VLL; MCUXPRESSO_SDK
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: board; .; CMSIS; component/lists; component/uart; device; drivers; utilities
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: $PROJ_FNAME$.bin
  ILINK.IlinkOutputFile: continuous_sram_address.out
  ILINK.IlinkIcfFile: MCXA156/iar/MCXA156_flash.icf
  ILINK.IlinkExtraOptions: --cpu=Cortex-M33.no_se
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration release (ARM)
  as the first configuration, except:
  General.CoreVariant: 58
  ICCARM.CCDefines: PRINTF_FLOAT_ENABLE=0; SCANF_FLOAT_ENABLE=0; PRINTF_ADVANCED_ENABLE=0; SCANF_ADVANCED_ENABLE=0; CPU_MCXA156VLL; MCUXPRESSO_SDK
  ICCARM.CCOptLevel: 3
  group board
    board/: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h
  group CMSIS
    CMSIS/: cmsis_compiler.h cmsis_iccarm.h cmsis_version.h core_cm33.h mpu_armv8.h tz_context.h
  group component/lists
    component/lists/: fsl_component_generic_list.c fsl_component_generic_list.h
  group component/uart
    component/uart/: fsl_adapter_lpuart.c fsl_adapter_uart.h
  group device
    device/: fsl_device_registers.h MCXA156.h MCXA156_features.h system_MCXA156.c system_MCXA156.h
  group drivers
    drivers/: fsl_clock.c fsl_clock.h fsl_cmc.c fsl_cmc.h fsl_common.c fsl_common.h fsl_common_arm.c fsl_common_arm.h fsl_edma.c fsl_edma.h fsl_edma_core.h fsl_edma_soc.c fsl_edma_soc.h fsl_gpio.c fsl_gpio.h fsl_lptmr.c fsl_lptmr.h fsl_lpuart.c fsl_lpuart.h fsl_port.h fsl_reset.c fsl_reset.h fsl_spc.c fsl_spc.h fsl_wuu.c fsl_wuu.h
  group MCXA156/iar
    MCXA156/iar/: MCXA156_flash.icf
  group source
    source/: continuous_sram_address.c
  group startup
    startup/: startup_MCXA156.s
  group utilities
    utilities/: fsl_assert.c fsl_assert.h fsl_debug_console.c fsl_debug_console.h fsl_str.c fsl_str.h
