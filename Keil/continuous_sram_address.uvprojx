# Keil uVision project continuous_sram_address.uvprojx, settings and files
target continuous_sram_address debug (6190000::V6.19::ARMCLANG)
  device: MCXA156VLL NXP
  pack: NXP.MCXA156_DFP.18.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU)  DSP
  output: continuous_sram_address.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG, PRINTF_FLOAT_ENABLE=0, SCANF_FLOAT_ENABLE=0, PRINTF_ADVANCED_ENABLE=0, SCANF_ADVANCED_ENABLE=0, CPU_MCXA156VLL, MCUXPRESSO_SDK
  c misc: -fno-common -fdata-sections -fno-builtin -mthumb
  c include: board;.;CMSIS;component/lists;component/uart;device;drivers;utilities
  asm define: CPU_LPC55S69JBD100_cm33_core0, DEBUG,__CC_ARM,KEIL
  library: MicroLIB
  memory RVCT1: ROM 0x0 size 0x100000
  memory RVCT4: ROM 0x3000000 size 0x2000
  memory RVCT5: ROM 0x13000000 size 0x2000
  memory RVCT9: RAM 0x20000000 size 0x1e000
  memory RVCT10: RAM 0x4000000 size 0x3000
  scatter file: MCXA156/arm/MCXA156_flash.scf
  link misc: --remove --entry=Reset_Handler --diag_suppress 6314
--remove
  group board
    board/: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h
  group CMSIS
    CMSIS/: cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_version.h core_cm33.h mpu_armv8.h tz_context.h
  group component/lists
    component/lists/: fsl_component_generic_list.c fsl_component_generic_list.h
  group component/uart
    component/uart/: fsl_adapter_lpuart.c fsl_adapter_uart.h
  group device
    device/: fsl_device_registers.h MCXA156.h MCXA156_features.h system_MCXA156.c system_MCXA156.h
  group drivers
    drivers/: fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_common_arm.c fsl_common_arm.h fsl_gpio.c fsl_gpio.h fsl_lpuart.c fsl_lpuart.h fsl_port.h fsl_reset.c fsl_reset.h fsl_spc.c fsl_spc.h
    ./drivers/: fsl_cmc.c fsl_cmc.h fsl_edma.c fsl_edma.h fsl_edma_core.h fsl_edma_soc.c fsl_edma_soc.h fsl_lptmr.c fsl_lptmr.h fsl_wuu.c fsl_wuu.h
  group source
    ./source/: continuous_sram_address.c
  group startup
    startup/: startup_MCXA156.S
  group utilities
    utilities/: fsl_assert.c fsl_assert.h fsl_debug_console.c fsl_debug_console.h fsl_str.c fsl_str.h
target continuous_sram_address release (6130001::V6.13.1::.\ARMCLANG)
  device: MCXA156VLL NXP
  pack: NXP.MCXA156_DFP.18.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU)  DSP
  output: continuous_sram_address.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: PRINTF_FLOAT_ENABLE=0, SCANF_FLOAT_ENABLE=0, PRINTF_ADVANCED_ENABLE=0, SCANF_ADVANCED_ENABLE=0, CPU_MCXA156VLL, MCUXPRESSO_SDK
  c misc: -fno-common -fdata-sections -fno-builtin -mthumb
  c include: as above
  asm define: CPU_LPC55S69JBD100_cm33_core0, NDEBUG,__CC_ARM,KEIL
  library: MicroLIB
  memory RVCT1: ROM 0x0 size 0x100000
  memory RVCT4: ROM 0x3000000 size 0x2000
  memory RVCT5: ROM 0x13000000 size 0x2000
  memory RVCT9: RAM 0x20000000 size 0x1e000
  memory RVCT10: RAM 0x4000000 size 0x3000
  scatter file: MCXA156/arm/MCXA156_flash.scf
  link misc: --remove --entry=Reset_Handler --diag_suppress 6314
--remove
